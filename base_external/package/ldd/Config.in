## base_external/package/ldd/Config.in
```kconfig
config BR2_PACKAGE_LDD
	bool "ldd"
	help
	  Builds and installs LDD misc-modules and scull kernel modules.
```
